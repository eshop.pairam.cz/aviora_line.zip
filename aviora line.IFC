Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: aviora line.IFC
Time: 2018-03-08T10:11:58
Written by: SwIFC
Made in: SolidWorks 2018

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: aviora line
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
